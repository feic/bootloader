# Keil uVision project bootloader.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: bootloader +hex
  AfterMake: E:\Keil\ARM\BIN40\fromelf.exe --bin -o ./bootloader.bin ./bootloader.axf
  c flags: Optim=4
  c include: .\inc;.\src;.\usb;..\bootloader
  asm include: .\inc
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x400000
  memory RVCT6: RAM 0x30000000 size 0x4000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group inc
    ./inc/: 2440addr.h 2440addr.inc 2440lib.h bootpara.h def.h Memcfg.inc Option.inc Option.h Nand.h
  group src
    ./src/: 2440init.s 2440lib.c nand.c nand_lowlevel.c u2440mon.c
